require quilt-release-git.inc
