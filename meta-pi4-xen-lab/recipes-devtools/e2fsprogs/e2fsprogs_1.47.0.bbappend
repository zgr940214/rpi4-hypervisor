# Poky's SRCREV is the annotated v1.47.0 tag object. Pin its exact peeled
# commit so shallow mirror clones can check out the same source tree.
SRCREV = "25ad8a431331b4d1d444a70b6079456cc612ac40"
